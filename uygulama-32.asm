	LIST P=16F877A
	#INCLUDE <P16F877A.INC>
	__CONFIG H'3F31'
	ORG 0X00
	GOTO ANA_METOT
	
ANA_METOT
	BANKSEL TRISB
	CLRF TRISB
	MOVLW B'00000011'
	MOVWF TRISD
	BANKSEL PORTB
	CLRF PORTB
	MOVLW B'00000011'
	MOVWF PORTD

KONTROL
	BTFSC PORTD,0
	GOTO K_E
	BTFSC PORTD,1
	GOTO K_S
	GOTO KONTROL_TEMIZLE
	GOTO KONTROL

K_E
	MOVLW B'01111001'
	MOVWF PORTB
	GOTO KONTROL

K_S
	MOVLW B'01101101'
	MOVWF PORTB
	GOTO KONTROL

KONTROL_TEMIZLE
	CLRF PORTB
	GOTO KONTROL

END